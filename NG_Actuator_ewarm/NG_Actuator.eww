<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\NG_Actuator.ewp</path>
    </project>
</workspace>